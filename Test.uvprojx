# Keil uVision project Test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: WDT_Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\H;.\CMSIS;..\W7901;.\Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./C/: main.C Uart.c iap.c
    ./H/: iap.h
  group STARTUP
    ./: startup_w1251.s
  group Driver
    ./C/: SC32F10xx_rcc.c
    ./Driver/src/: SC32F10xx_gpio.c
    ./H/: W1251.h
